FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# SRC_URI += "file://0001-adding-fclk-to-dtsi.patch"

SRC_URI += "file://0002-adding-support-for-sc18is606.patch"

