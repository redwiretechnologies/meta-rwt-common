BBCLASSEXTEND = "native"
RDEPENDS:${PN}_class-native = ""
