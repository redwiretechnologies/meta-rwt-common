PACKAGECONFIG = " network_backend serial_backend xml_backend libiio-python3"
DEPENDS:append = " libusb1"
