RDEPENDS_packagegroup-sdr-base-extended_remove = "resolvconf"
